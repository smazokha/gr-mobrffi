options:
  parameters:
    author: Stepan Mazokha
    generate_options: qt_gui
    id: gr_mobrffi_demo
    output_language: python
    title: MobRFFI Re-identification
  states: {}

blocks:
- name: threshold
  id: variable
  parameters:
    value: '0.497'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '400'
    type: complex
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '1.25'
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '1000'
    type: float
  states: {state: disabled}
- name: mobrffi_cfo_estimator_0
  id: mobrffi_cfo_estimator
  parameters:
    lag: '16'
    sampleRate: '25000000'
    vectorLength: '400'
  states: {state: disabled}
- name: mobrffi_get_fingerprint_0
  id: mobrffi_get_fingerprint
  parameters:
    computeMode: GPU
    embeddingLength: '512'
    modelPath: /home/smazokha/Downloads/model.onnx
    specWidth: '80'
    vectorLength: '400'
  states: {}
- name: mobrffi_label_demo_0
  id: mobrffi_label_demo
  parameters:
    maxLabelCount: '12'
  states: {}
- name: mobrffi_reid_0
  id: mobrffi_reid
  parameters:
    chromaPath: /home/smazokha/Downloads/mobrffi_chroma
    collectionName: mobrffi
    cosineThreshold: threshold
    embeddingLength: '512'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '9000'
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    size: '1000'
    srate: '1000'
    type: float
    update_time: '0.001'
    ylabel: CFO, Hz
    ymax: '20000000'
    ymin: '0'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '5'
    type: ccc
  states: {}

connections:
- [blocks_repeat_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_vector_2, '0', mobrffi_get_fingerprint_0, '0']
- [blocks_tagged_stream_align_0, '0', rational_resampler_xxx_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_stream_to_vector_2, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [mobrffi_cfo_estimator_0, '0', blocks_repeat_0, '0']
- [mobrffi_get_fingerprint_0, '0', mobrffi_reid_0, '0']
- [mobrffi_reid_0, '0', mobrffi_label_demo_0, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_align_0, '0']
- [rational_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
